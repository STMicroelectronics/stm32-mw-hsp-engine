# IAR project Project.ewp, settings and files
configuration CCC_Valid (ARM, debug)
  General.OGChipSelectEditMenu: STM32U3C5ZI ST STM32U3C5ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U3C5xx; USER_VECT_TAB_ADDRESS; USE_FULL_HAL_DRIVER; USE_FULL_LL_DRIVER; _ENABLE_HAL_REGISTER_CALLBACKS; GCC_COMPILE; ARM_COMPILE; IAR_BUILD; USE_HAL_HSP_CUBE1_LEGACY
  ICCARM.CCIncludePath2: ..\conf_u3; ..\conf_mw; ..\..\Drivers\CMSIS\Device\ST\STM32U3xx\Include; ..\..\Drivers\STM32U3xx_HAL_Driver\Inc; ..\..\Drivers\CMSIS\Core\Include; ..\..\Drivers\CMSIS\DSP\Include; ..\..\Drivers\HAL_HSP_Proposal; ..\..\..\common\modules\firmware\crom_1.1.7\cram_1.7; ..\..\..\common\core; ..\..\..\common\proclist; ..\..\..\common\utilities; ..\..\..\common\modules; ..\..\..\common\modules\cnn_lib; ..\..\..\common\modules\direct_lib; ..\..\..\common\modules\dsp_lib; ..\..\..\common\modules\proclist_lib; ..\..\..\interfaces; ..\..\..\interfaces\user_defined
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\Drivers\CMSIS\Device\ST\STM32U3xx\Source\Templates\iar\linker\stm32u3c5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/CCC Valid
    ../MW/: hsp_test.c hsp_test_common.c hsp_test_main_mdw.c
    ../../../../../../../../../Users/assematv/Downloads/: system_clock_custom.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_exti.c stm32u3xx_hal_gpio.c stm32u3xx_hal_hsp.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c
  group Middleware
    ../../../common/core/: hsp_bram.c hsp_core.c
    ../../../common/proclist/: hsp_proclist.c
  group Middleware/Interfaces
    ../../../interfaces/: hsp_bram_if.c hsp_hw_if.c hsp_utilities.c
    ../../../common/utilities/: hsp_memcpy.c
    ../../../common/utilities/portable/IAR/: st_hsp_memcpy32.s
  group Middleware/Modules/CNN LIB
    ../../../common/modules/cnn_lib/: hsp_cnn.c
  group Middleware/Modules/Direct LIB
    ../../../common/modules/direct_lib/: hsp_direct_command.c
  group Middleware/Modules/Dsp_LIB
    ../../../common/modules/dsp_lib/: hsp_dsp.c
  group Middleware/Modules/Firmware
    ../../../common/modules/firmware/crom_1.1.7/cram_1.7/: hsp_fw_ram.c
  group Middleware/Modules/Proclist LIB
    ../../../common/modules/proclist_lib/: hsp_proclist_complex.c hsp_proclist_conditional.c hsp_proclist_filter.c hsp_proclist_matrix.c hsp_proclist_scalar.c hsp_proclist_transform.c hsp_proclist_vector.c
  group System/STM32U3xx
    ../conf_u3/: stm32u3xx_hal_msp.c stm32u3xx_it.c
  group System/STM32U3xx/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32U3xx/Source/Templates/iar/: startup_stm32u3c5xx.s
    ../../Drivers/CMSIS/Device/ST/STM32U3xx/Source/Templates/: system_stm32u3xx.c
