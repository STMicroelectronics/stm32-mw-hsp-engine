# IAR project mw_hsp_valid.ewp, settings and files
configuration MW_VALID_U3 (ARM, debug)
  General.OGChipSelectEditMenu: STM32U3C5ZI ST STM32U3C5ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: MW_VALID_U3; USER_VECT_TAB_ADDRESS; USE_FULL_HAL_DRIVER; USE_FULL_LL_DRIVER; ENABLE_HAL_REGISTER_CALLBACKS; ARM_COMPILE; USE_HSP_ACC_COMMAND_SYNCHRONOUS; USE_HAL_HSP_CUBE1_LEGACY; STM32U3C5xx; USE_HSP_ASSERT_DBG_PARAM=1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\; ..\..\; ..\..\..\; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\DSP\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U3xx\Include; ..\..\..\..\..\..\..\Drivers\STM32U3xx_HAL_Driver\Inc; ..\..\..\..\common; ..\..\..\..\common\core; ..\..\..\..\common\proclist; ..\..\..\..\common\modules\; ..\..\..\..\common\modules\direct_lib\; ..\..\..\..\common\modules\cnn_lib\; ..\..\..\..\common\modules\dsp_lib\; ..\..\..\..\common\modules\proclist_lib\; ..\..\..\..\common\modules\firmware\crom_1.1.7\cram_1.7\; ..\..\..\..\common\utilities\; ..\..\..\..\interfaces\; ..\valid_context; C:\git\stm32cube_fw_all\middleware\hsp_engine\common\monitoring
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32u3c5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Source/Templates/iar/: startup_stm32u3c5xx.s
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32U3xx/Source/Templates/: system_stm32u3xx.c
  group Drivers/stm32u3xx_hal
    ../../../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_cortex.c stm32u3xx_hal_exti.c stm32u3xx_hal_hsp.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c
  group Middlewares/HSP Engine/common/core
    ../../../../common/core/: hsp_bram.c hsp_core.c
  group Middlewares/HSP Engine/common/modules/CNN
    ../../../../common/modules/cnn_lib/: hsp_cnn.c
  group Middlewares/HSP Engine/common/modules/direct command
    ../../../../common/modules/direct_lib/: hsp_direct_command.c
  group Middlewares/HSP Engine/common/modules/dsp
    ../../../../common/modules/dsp_lib/: hsp_dsp.c
  group Middlewares/HSP Engine/common/modules/proclist
    ../../../../common/modules/proclist_lib/: hsp_proclist_complex.c hsp_proclist_conditional.c hsp_proclist_filter.c hsp_proclist_matrix.c hsp_proclist_scalar.c hsp_proclist_transform.c hsp_proclist_vector.c
  group Middlewares/HSP Engine/common/monitoring
    ../../../../common/monitoring/: hsp_monitoring.c
  group Middlewares/HSP Engine/common/proclist
    ../../../../common/proclist/: hsp_proclist.c
  group Middlewares/HSP Engine/common/utilities
    ../../../../common/utilities/: hsp_memcpy.c
  group Middlewares/HSP Engine/common/utilities/IAR
    ../../../../common/utilities/portable/IAR/: st_hsp_memcpy32.s
  group Middlewares/HSP Engine/interfaces
    ../../../../interfaces/: hsp_bram_if.c hsp_hw_if.c hsp_utilities.c
  group Validation_HSP_Engine
    ../../: mw_hsp_valid.c mw_hsp_valid_assert.c mw_hsp_valid_e_assert.c mw_hsp_valid_init.c mw_hsp_valid_memcpy.c mw_hsp_valid_stream_buffer.c mw_hsp_valid_test_log.c mw_hsp_valid_testslist.c
  group Validation_HSP_Engine/U3-2M
    ../valid_context/: mw_hsp_valid_hsp1.c mw_hsp_valid_it.c
  group Validation_HSP_Engine/U3-2M/HSP Firmware/crom_v1.1.7/cram_v1.6
    ../../../../common/modules/firmware/crom_1.1.7/cram_1.6/: hsp_fw_ram.c
  group Validation_HSP_Engine/U3-2M/HSP Firmware/crom_v1.1.7/cram_v1.7
    ../../../../common/modules/firmware/crom_1.1.7/cram_1.7/: hsp_fw_ram.c
